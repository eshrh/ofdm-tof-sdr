options:
  parameters:
    generate_options: no_gui
    id: txrx
    output_language: python
    title: TXRX
  states: {}

blocks:
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.005'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '64'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: center_freq
  id: parameter
  parameters:
    value: 2e9
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
    packet_len_key: '"packet_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ((-21, -7, 7, 21,),)
    pilot_symbols: ((1, 1, 1, -1,),)
    rolloff: '0'
    sync_word1: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
    sync_word2: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0]'
  states: {}
- name: external_clock
  id: parameter
  parameters:
    label: external clock
    type: intx
    value: '0'
  states: {}
- name: rx_chain_0
  id: rx_chain
  parameters:
    fft_len: '64'
    port: '2001'
    samp_rate: samp_rate
  states: {}
- name: rx_chain_1
  id: rx_chain
  parameters:
    fft_len: '64'
    port: '2000'
    samp_rate: 2e6
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: sdr_0
  id: parameter
  parameters:
    label: sdr 0
    type: str
    value: serial= 316405A
  states: {}
- name: sdr_1
  id: parameter
  parameters:
    label: sdr 1
    type: str
    value: serial= 316407B
  states: {}
- name: sdr_channel_0
  id: parameter
  parameters:
    label: sdr channel 0
    type: intx
    value: '0'
  states: {}
- name: sdr_channel_1
  id: parameter
  parameters:
    label: sdr channel 1
    type: intx
    value: '0'
  states: {}
- name: sinksource_0
  id: sinksource
  parameters:
    center_freq: center_freq
    channel: sdr_channel_0
    external_clock: external_clock
    samp_rate: samp_rate
    sdr: sdr_0
    sync: sync
  states: {}
- name: sinksource_1
  id: sinksource
  parameters:
    center_freq: center_freq
    channel: sdr_channel_1
    external_clock: external_clock
    samp_rate: samp_rate
    sdr: sdr_1
    sync: sync
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: gr.logging().set_default_level(gr.log_levels.warn)
    section: init_before_blocks
  states: {}
- name: sync
  id: parameter
  parameters:
    label: sync
    type: str
    value: '"pc"'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:1234
    timeout: '100'
  states: {}
- name: zeromq_sub_msg_source_1
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:1235
    timeout: '100'
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', sinksource_0, '0']
- [blocks_selector_0, '1', sinksource_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_tag_gate_0, '0', rx_chain_1, '0']
- [blocks_tag_gate_1, '0', rx_chain_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [sinksource_0, '0', blocks_tag_gate_0, '0']
- [sinksource_1, '0', blocks_tag_gate_1, '0']
- [zeromq_sub_msg_source_0, out, blocks_selector_0, oindex]
- [zeromq_sub_msg_source_1, out, sinksource_0, msg_in]
- [zeromq_sub_msg_source_1, out, sinksource_0, msg_in2]
- [zeromq_sub_msg_source_1, out, sinksource_1, msg_in]
- [zeromq_sub_msg_source_1, out, sinksource_1, msg_in2]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
