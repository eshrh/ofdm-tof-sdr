options:
  parameters:
    description: a sink and a source!
    generate_options: hb
    id: sinksource
    output_language: python
    title: sinksource
  states: {}

blocks:
- name: center_freq
  id: parameter
  parameters:
    type: eng_float
    value: 2e9
  states: {}
- name: channel
  id: parameter
  parameters:
    label: RF channel (0 or 1)
    type: intx
    value: '0'
  states: {}
- name: external_clock
  id: parameter
  parameters:
    label: external clock
    type: intx
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: msg_in
    optional: 'True'
    type: message
  states: {}
- name: pad_source_1_0
  id: pad_source
  parameters:
    label: msg_in2
    optional: 'True'
    type: message
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp rate
    type: eng_float
    value: 2e6
  states: {}
- name: sdr
  id: parameter
  parameters:
    label: sdr_address
    type: str
    value: '""'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      if external_clock:
          self.uhd_usrp_sink_node1.set_clock_source("external", 0)
          self.uhd_usrp_source_node1.set_clock_source("external", 0)
      else:
          self.uhd_usrp_sink_node1.set_clock_source("internal", 0)
          self.uhd_usrp_source_node1.set_clock_source("internal", 0)

      if sync == "pc":
          self.uhd_usrp_sink_node1.set_time_now(uhd.time_spec(time.time()), uhd.ALL_MBOARDS)
          self.uhd_usrp_source_node1.set_time_now(uhd.time_spec(time.time()), uhd.ALL_MBOARDS)
      elif sync == "pps":
          self.uhd_usrp_sink_node1.set_time_unknown_pps(uhd.time_spec(0))
          self.uhd_usrp_source_node1.set_time_unknown_pps(uhd.time_spec(0))
    section: main_after_init
  states: {}
- name: sync
  id: parameter
  parameters:
    label: sync
    type: str
    value: '""'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: center_freq
    clock_source0: '"external" if external_clock==1 else "internal"'
    dev_addr: sdr
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: '"A:A" if channel == 0 else "A:B"'
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: center_freq
    clock_source0: '"external" if external_clock==1 else "internal"'
    dev_addr: sdr
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sd_spec0: '"A:A" if channel==0 else "A:B"'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [pad_source_0, '0', uhd_usrp_sink_0, '0']
- [pad_source_1, out, uhd_usrp_sink_0, command]
- [pad_source_1_0, out, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
